COMPATIBLE_MACHINE += "cronos-hw-v2"
