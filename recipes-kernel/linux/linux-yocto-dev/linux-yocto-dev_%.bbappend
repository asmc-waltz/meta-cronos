FILESEXTRAPATHS:append := "${THISDIR}/files:"

